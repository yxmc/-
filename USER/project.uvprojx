# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\USER;..\LIB\inc;..\HARDWARE;..\SYSTEM;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\AS608;..\HARDWARE\OLED_SPI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group LIB
    ../LIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_flash.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_i2c.c
    ../../位带/LIB/src/: stm32f4xx_exti.c
    ../../中断/LIB/src/: stm32f4xx_tim.c
    ../../Timer/LIB/src/: stm32f4xx_usart.c
  group HARDWARE
    ../HARDWARE/: led.c beep.c key.c timer.c key_board_3x4.c pwm.c dht11.c sr04.c iwdg.c wwdg.c flash.c rtc.c adc.c spi.c w25qxxx.c MFRC522.c at24cxx.c iic.c
    ../HARDWARE/MPU6050/: mpu6050.c mpu_iic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/OLED_SPI/: OLED.c OLED_Data.c
  group SYSTEM
    ../SYSTEM/: system.c SysTick.c usart.c
